# Keil uVision project rtthread-nano.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: GD32F150C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x02000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-nano
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: GD32F1x0, GD32F130_150,
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\Peripherals\inc;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.3.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group CMSIS
    ../Firmware/CMSIS/: system_gd32f1x0.c
    ../Firmware/CMSIS/ARM/: startup_gd32f1x0.s
  group Libraries
    ../Firmware/Peripherals/src/: gd32f1x0_misc.c gd32f1x0_rcc.c gd32f1x0_usart.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_gpio.c gd32f1x0_exti.c
  group User
    ../User/: gd32f1x0_it.c main.c uart.c
software components: RTOS:device drivers 2.1.2, RTOS:kernel 2.1.2, RTOS:shell 2.1.2
